IMAGE_INSTALL_append += "self-tests"
IMAGE_INSTALL_append += "connector-tests"

